<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>nwr_fg</value></param>
<param><key>author</key><value>Andy Walls</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>comment</key><value>NOAA Weather Radio Receiver
(C) 2016 Andy Walls &lt;awalls.cx18@gmail.com&gt;
This flowgraph and grc data file were generated
by Andy Walls using the GNU Radio Companion
application.
See http://www.gnu.org/licenses/gpl-faq.en.html#GPLOutput</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>max_nouts</key><value>int(aud_fs/10.0)*5</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>NOAA Weather Radio Receiver</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>antialias_filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass_2(1, fm_fs, 2.0*same_fd, same_fd/2.0, 20, firdes.WIN_BLACKMAN_HARRIS)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>antialias_filter_taps_len</value></param>
<param><key>value</key><value>len(antialias_filter_taps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>aud_f_center</value></param>
<param><key>value</key><value>(aud_f_space + aud_f_mark)/2.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>aud_f_mark</value></param>
<param><key>value</key><value>4.0/symbol_period</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>aud_f_space</value></param>
<param><key>value</key><value>3.0/symbol_period</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>aud_fs</value></param>
<param><key>value</key><value>16000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>tabset0@0:0,1,1,1</value></param>
<param><key>label</key><value>BB Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>60</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>beta</value></param>
<param><key>value</key><value>((fm_fs/2.0)/math.pi)/fm_deviation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>carson_bandwidth</value></param>
<param><key>value</key><value>2.0*(fm_deviation + 3e3)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>(162.475e6+162.500e6)/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass_2(1, samp_rate, 10000, 2000, 40, firdes.WIN_BLACKMAN_HARRIS)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_filter_taps_len</value></param>
<param><key>value</key><value>len(channel_filter_taps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>deemphasis_freq</value></param>
<param><key>value</key><value>300.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eta</value></param>
<param><key>value</key><value>1.0/math.sqrt(2.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fm_deviation</value></param>
<param><key>value</key><value>5000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fm_fs</value></param>
<param><key>value</key><value>25000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_mu</value></param>
<param><key>value</key><value>0.6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tabset0@2:1,1,1,1</value></param>
<param><key>label</key><value>Clock Recovery Gain Mu</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.001</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_mu</value></param>
<param><key>value</key><value>2.0*math.exp(-zeta*omega_n_norm)*math.sinh(zeta*omega_n_norm)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_omega</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tabset0@2:1,0,1,1</value></param>
<param><key>label</key><value>Clock Recovery Gain Omega</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.001</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_omega</value></param>
<param><key>value</key><value>2.0-gain_mu-2.0*math.exp(-zeta*omega_n_norm)*(math.cosh(omega_d_norm) if zeta &gt; 1.0 else math.cos(omega_d_norm))</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>tabset0@0:1,0,1,1</value></param>
<param><key>label</key><value>IF Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>60</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lbw</value></param>
<param><key>value</key><value>(-lbw_q_b-math.sqrt(lbw_q_b*lbw_q_b-4.0*lbw_q_a*lbw_q_c))/(2.0*lbw_q_a)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lbw_q_a</value></param>
<param><key>value</key><value>beta-4.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lbw_q_b</value></param>
<param><key>value</key><value>2*eta*beta</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lbw_q_c</value></param>
<param><key>value</key><value>beta</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>omega_d_norm</value></param>
<param><key>value</key><value>omega_n_norm*math.sqrt((zeta*zeta-1.0) if zeta &gt; 1.0 else (1.0-zeta*zeta))</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>omega_n_norm</value></param>
<param><key>value</key><value>2.0*math.pi*0.045</value></param>
<param><key>gui_hint</key><value>tabset0@2:1,1,1,1</value></param>
<param><key>label</key><value>Normalized Bandwidth</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>2.0*math.pi*0.25</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ppm_val</value></param>
<param><key>value</key><value>28</value></param>
<param><key>gui_hint</key><value>tabset0@0:1,1,1,1</value></param>
<param><key>label</key><value>RTL-SDR PPM Correction</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pulse_filter_taps</value></param>
<param><key>value</key><value>[1/round(sps)]*int(round(sps))</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>40</value></param>
<param><key>gui_hint</key><value>tabset0@0:0,0,1,1</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>60</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>same_f_mark</value></param>
<param><key>value</key><value>same_fd</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>same_f_space</value></param>
<param><key>value</key><value>-same_fd</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>same_fc</value></param>
<param><key>value</key><value>(aud_f_mark + aud_f_space)/2.0*0.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>same_fd</value></param>
<param><key>value</key><value>(aud_f_mark - aud_f_space)/2.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>same_fs</value></param>
<param><key>value</key><value>fm_fs/8.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>same_fs * symbol_period</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_period</value></param>
<param><key>value</key><value>1920.0e-6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>1.0/symbol_period</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tau</value></param>
<param><key>value</key><value>1.0/(2.0*math.pi*deemphasis_freq)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>w_n</value></param>
<param><key>value</key><value>2.0*fm_fs*math.tan((1.0/tau)/(fm_fs * 2.0))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wav_fs</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>wx_channel_freq</value></param>
<param><key>value</key><value>162.400e6</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>WX Channel</value></param>
<param><key>labels</key><value>["WX1 162.550 MHz", "WX2 162.400 MHz", "WX3 162.475 MHz", "WX4 162.425 MHz", "WX5 162.450 MHz", "WX6 162.500 MHz", "WX7 162.525 MHz"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[162.550e6, 162.400e6, 162.475e6, 162.425e6, 162.450e6, 162.500e6, 162.525e6]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>zeta</value></param>
<param><key>value</key><value>2.0</value></param>
<param><key>gui_hint</key><value>tabset0@2:1,0,1,1</value></param>
<param><key>label</key><value>Damping Factor</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.1</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>5.0</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>10**(40.0/10.0)</value></param>
<param><key>rate</key><value>1e-4</value></param>
<param><key>reference</key><value>math.sqrt(2.0)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_pll_carriertracking_cc</key>
<param><key>id</key><value>analog_pll_carriertracking_cc_0</value></param>
<param><key>w</key><value>math.pi/200.0</value></param>
<param><key>max_freq</key><value>math.pi/(fm_fs/2.0)*fm_fs/2.0*0.85</value></param>
<param><key>min_freq</key><value>-math.pi/(fm_fs/2.0)*fm_fs/2.0*0.85</value></param>
</block>
<block>
<key>analog_pll_freqdet_cf</key>
<param><key>id</key><value>analog_pll_freqdet_cf_0</value></param>
<param><key>w</key><value>lbw</value></param>
<param><key>max_freq</key><value>math.pi/(fm_fs/2.0)*carson_bandwidth/2.0</value></param>
<param><key>min_freq</key><value>-math.pi/(fm_fs/2.0)*carson_bandwidth/2.0</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>((fm_fs/2.0)/math.pi)/fm_deviation</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>device_name</key><value>plughw:0,0</value></param>
<param><key>samp_rate</key><value>aud_fs</value></param>
</block>
<block>
<key>blocks_abs_xx</key>
<param><key>id</key><value>blocks_abs_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_1</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>int(sps/2)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_meta_sink</key>
<param><key>id</key><value>blocks_file_meta_sink_0</value></param>
<param><key>detached</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>extra_dict</key><value>""</value></param>
<param><key>file</key><value>/home/andy/grcs/nwr_band_162487500Hz_250ksps_201611091200.c32</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>max_seg_size</key><value>1000000</value></param>
<param><key>rel_rate</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_file_meta_source</key>
<param><key>id</key><value>blocks_file_meta_source_0</value></param>
<param><key>detached</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/andy/grcs/nwr_band_162487500Hz_250ksps_201611091145.c32</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>int(fm_fs/1000.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0</value></param>
<param><key>n</key><value>int(fm_fs/1000.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>int(sps*1.0)</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1.0/(sps*1.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>1.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10.0</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0_0</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10.0</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0_1</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10.0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>interp</key><value>int(aud_fs/1000.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0_0</value></param>
<param><key>interp</key><value>int(aud_fs/1000.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>Correction Estimator Out</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>0.075</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>0.075</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0</value></param>
<param><key>high</key><value>-30.0</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>-30.0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>fm_fs</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/andy/grcs/Same.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>analog_pll_carriertracking_cc</key>
<param><key>id</key><value>coherent_mark_pll</value></param>
<param><key>w</key><value>4.0*same_fd*0.10*math.pi/(same_fs/2.0)</value></param>
<param><key>max_freq</key><value>(same_fc - same_fd*0.90)*math.pi/(same_fs/2.0)</value></param>
<param><key>min_freq</key><value>(same_fc - same_fd*1.10)*math.pi/(same_fs/2.0)</value></param>
</block>
<block>
<key>analog_pll_carriertracking_cc</key>
<param><key>id</key><value>coherent_space_pll</value></param>
<param><key>w</key><value>4.0*same_fd*0.10*math.pi/(same_fs/2.0)</value></param>
<param><key>max_freq</key><value>(same_fc+same_fd*1.1)*math.pi/(same_fs/2.0)</value></param>
<param><key>min_freq</key><value>(same_fc+same_fd*0.90)*math.pi/(same_fs/2.0)</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_bb</key>
<param><key>id</key><value>digital_correlate_access_code_tag_bb_0</value></param>
<param><key>access_code</key><value>"101010111010101110101011"</value></param>
<param><key>tagname</key><value>rx_start</value></param>
<param><key>threshold</key><value>0</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0_0_3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_delay</key><value>int((len(pulse_filter_taps)-1)/2.0)</value></param>
<param><key>taps</key><value>pulse_filter_taps</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fractional_resampler_xx</key>
<param><key>id</key><value>fractional_resampler_xx_0</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>resamp_ratio</key><value>float(fm_fs)/float(aud_fs)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>fractional_resampler_xx</key>
<param><key>id</key><value>fractional_resampler_xx_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>resamp_ratio</key><value>float(wav_fs)/float(fm_fs)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>freq_xlating_fft_filter_ccc_0</value></param>
<param><key>center_freq</key><value>wx_channel_freq-center_freq</value></param>
<param><key>decim</key><value>int(samp_rate/fm_fs)</value></param>
<param><key>samp_delay</key><value>(channel_filter_taps_len - 1)/2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>channel_filter_taps</value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>freq_xlating_fft_filter_ccc_1</value></param>
<param><key>center_freq</key><value>aud_f_center</value></param>
<param><key>decim</key><value>int(fm_fs/same_fs)</value></param>
<param><key>samp_rate</key><value>fm_fs</value></param>
<param><key>taps</key><value>antialias_filter_taps</value></param>
</block>
<block>
<key>goertzel_fc</key>
<param><key>id</key><value>goertzel_fc_0</value></param>
<param><key>freq</key><value>1050.0</value></param>
<param><key>len</key><value>int(aud_fs*0.10)</value></param>
<param><key>rate</key><value>int(aud_fs)</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>iir_filter_xxx_0</value></param>
<param><key>fftaps</key><value>[(w_n/(2.0*fm_fs))/(1.0 + (w_n/(2.0*fm_fs))), (w_n/(2.0*fm_fs))/(1.0 + (w_n/(2.0*fm_fs)))]</value></param>
<param><key>fbtaps</key><value>[1, -(1.0 - (w_n/(2.0*fm_fs)))/(1.0 + (w_n/(2.0*fm_fs)))]</value></param>
<param><key>oldstyle</key><value>False</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>iir_filter_xxx_0_0_0</value></param>
<param><key>fftaps</key><value>[0.011510566463773506, 0.06906339878264117, 0.17265849695660299, 0.23021132927547108, 0.1726584969566033, 0.06906339878264137, 0.011510566463773575]</value></param>
<param><key>fbtaps</key><value> [1.0, -1.0761860182492677, 1.210701537838693, -0.5925674861028039, 0.23485515951574346, -0.044490863792654226, 0.004363924471791554]</value></param>
<param><key>oldstyle</key><value>False</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>iir_filter_xxx_1</value></param>
<param><key>fftaps</key><value>[0.023509238376417288, -0.07188147642457338, 0.17072372741918906, -0.27322541811187256, 0.34892182153177714, -0.34892182153177737, 0.2732254181118729, -0.17072372741918962, 0.0718814764245737, -0.023509238376417475]</value></param>
<param><key>fbtaps</key><value> [1.0, 1.7412704310498077, 4.269108722970966, 5.166447090964201, 6.352585132027105, 5.341062524163067, 3.940483369625517, 2.154707182452647, 0.8564631011627446, 0.2386297334289591]</value></param>
<param><key>oldstyle</key><value>False</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>De-emphasis filter</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>Bilinear transformation</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0</value></param>
<param><key>note</key><value>Coherent FSK demod</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0</value></param>
<param><key>note</key><value>Bilinear transformation</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_1</value></param>
<param><key>note</key><value>SAME demodulation chain</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_1_0</value></param>
<param><key>note</key><value>Butterworth, Stop 3500 Hz, Pass 3000 Hz, Pass 1.0 dB, Stop 6.0 dB, 16 ksps</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1</value></param>
<param><key>note</key><value>Automatic Frequency Control</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0</value></param>
<param><key>note</key><value>Channelizer</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_1</value></param>
<param><key>note</key><value>FM Detector</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_2</value></param>
<param><key>note</key><value>Automatic Gain Control</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_2</value></param>
<param><key>note</key><value>Elliptic Filter, 4-8 KHz</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>FM Channel Carrier Lock Detector</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0</value></param>
<param><key>note</key><value>signal and noise power</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_0</value></param>
<param><key>note</key><value>Audio LPF</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_0_0</value></param>
<param><key>note</key><value>Final gain stage</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_1</value></param>
<param><key>note</key><value>Audio N in 4 kHz</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_1_0</value></param>
<param><key>note</key><value>Audio S+N in 4 kHz</value></param>
</block>
<block>
<key>nwr_add_tag_value_ff</key>
<param><key>id</key><value>nwr_add_tag_value_ff_0</value></param>
<param><key>tagname</key><value>"offset_corr"</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>nwr_burst_detect_and_tag</key>
<param><key>id</key><value>nwr_burst_detect_and_tag_0</value></param>
<param><key>guard_interval</key><value>0.1</value></param>
<param><key>declare_dur</key><value>symbol_period*8.0*16.0</value></param>
<param><key>eob_delay</key><value>symbol_period*4.0</value></param>
<param><key>eob_key</key><value>"rx_eob"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>init_floor_est</key><value>0.015</value></param>
<param><key>max_dur</key><value>symbol_period*8.0*268.0</value></param>
<param><key>sob_amp_frac</key><value>0.0</value></param>
<param><key>sample_rate</key><value>same_fs</value></param>
<param><key>sob_key</key><value>"rx_sob"</value></param>
<param><key>thresh_db</key><value>0.0</value></param>
</block>
<block>
<key>nwr_clock_recovery_mm_xx</key>
<param><key>id</key><value>nwr_clock_recovery_mm_xx_0</value></param>
<param><key>damping</key><value>zeta</value></param>
<param><key>type</key><value>ff</value></param>
<param><key>loop_bw</key><value>omega_n_norm</value></param>
<param><key>max_dev</key><value>1.0</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>nwr_correction_estimator_ff</key>
<param><key>id</key><value>nwr_correction_estimator_ff_0</value></param>
<param><key>clock_est_key</key><value>"clock_est"</value></param>
<param><key>eob_key</key><value>"rx_eob"</value></param>
<param><key>peak_ref</key><value>1.0</value></param>
<param><key>trough_ref</key><value>-0.65</value></param>
<param><key>inspection_length</key><value>int(sps*8*4)</value></param>
<param><key>offset_corr_key</key><value>"offset_corr"</value></param>
<param><key>scale_corr_key</key><value>"scale_corr"</value></param>
<param><key>scale_eob_zero</key><value>False</value></param>
<param><key>sob_key</key><value>"rx_sob"</value></param>
<param><key>timing_win_end</key><value>int(sps*7)</value></param>
<param><key>timing_win_start</key><value>int(sps*3)</value></param>
<param><key>time_est_key</key><value>"time_est"</value></param>
</block>
<block>
<key>nwr_multiply_by_tag_value_ff</key>
<param><key>id</key><value>nwr_multiply_by_tag_value_ff_0</value></param>
<param><key>tagname</key><value>"scale_corr"</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>nwr_same_burst_decoder</key>
<param><key>id</key><value>nwr_same_burst_decoder_0</value></param>
<param><key>eob_key</key><value>"rx_eob"</value></param>
<param><key>sob_key</key><value>"rx_sob"</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>bb_gain</value></param>
<param><key>corr0</key><value>ppm_val</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>if_gain</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>tabset0@2:0,0,1,1</value></param>
<param><key>label1</key><value>Unfiltered SAME I/Q</value></param>
<param><key>name</key><value>"SAME Signal Trajectory"</value></param>
<param><key>size</key><value>160*3</value></param>
<param><key>tr_level</key><value>0.15</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>tabset0@2:2,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>Recovered Symbols</value></param>
<param><key>name</key><value>"FSK Constellation"</value></param>
<param><key>size</key><value>150</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>tr_tag</key><value>"rx_start"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.02</value></param>
<param><key>xmax</key><value>1.5</value></param>
<param><key>xmin</key><value>-1.5</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-0.5</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabset0@0:2,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>RF Spectrum</value></param>
<param><key>name</key><value>RF Spectrum for Channels WX1 - WX7</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>wintype</key><value>firdes.WIN_KAISER</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0_0_0</value></param>
<param><key>bw</key><value>aud_fs</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabset0@1:0,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>After Deepmhasis</value></param>
<param><key>label2</key><value>After Audio LPF</value></param>
<param><key>label3</key><value>After Final Gain</value></param>
<param><key>name</key><value>Audio Sprectra</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>freqhalf</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_KAISER</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0_0_0_0</value></param>
<param><key>bw</key><value>fm_fs</value></param>
<param><key>fc</key><value>wx_channel_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabset0@0:2,1,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>RF Spectrum</value></param>
<param><key>label2</key><value>Tracked RF Spectrum</value></param>
<param><key>name</key><value>WX Channel RF Spectrum</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_KAISER</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>gui_hint</key><value>tabset0@0:2,2,1,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_VERT</value></param>
<param><key>type</key><value>float</value></param>
<param><key>color1</key><value>("blue", "red")</value></param>
<param><key>label1</key><value>Raw</value></param>
<param><key>label2</key><value>Thresholded</value></param>
<param><key>max</key><value>1.0</value></param>
<param><key>min</key><value>0.0</value></param>
<param><key>name</key><value>"Carrier Lock Detect"</value></param>
<param><key>nconnections</key><value>2</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0</value></param>
<param><key>gui_hint</key><value>tabset0@0:2,3,1,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_VERT</value></param>
<param><key>type</key><value>float</value></param>
<param><key>color1</key><value>("blue", "red")</value></param>
<param><key>label1</key><value>10*log10(S+N)</value></param>
<param><key>unit1</key><value>dBFS</value></param>
<param><key>max</key><value>0.0</value></param>
<param><key>min</key><value>-80.0</value></param>
<param><key>name</key><value>"RSSI"</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0_0</value></param>
<param><key>gui_hint</key><value>tabset0@1:0,2,1,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_VERT</value></param>
<param><key>type</key><value>float</value></param>
<param><key>color1</key><value>("blue", "red")</value></param>
<param><key>label1</key><value>Raw</value></param>
<param><key>unit1</key><value>dBFS</value></param>
<param><key>max</key><value>0.0</value></param>
<param><key>min</key><value>-80.0</value></param>
<param><key>name</key><value>"EAS Tone"</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0_0_0</value></param>
<param><key>gui_hint</key><value>tabset0@1:0,3,1,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_VERT</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>Presence</value></param>
<param><key>unit1</key><value>GO/NOGO</value></param>
<param><key>max</key><value>1.0</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>"EAS Tone"</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0_0_1</value></param>
<param><key>gui_hint</key><value>tabset0@1:0,4,1,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_VERT</value></param>
<param><key>type</key><value>float</value></param>
<param><key>color1</key><value>("blue", "red")</value></param>
<param><key>label1</key><value>log10(S/N+1)</value></param>
<param><key>unit1</key><value>dB</value></param>
<param><key>max</key><value>40.0</value></param>
<param><key>min</key><value>0.0</value></param>
<param><key>name</key><value>"Audio S/N+1"</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>tabset0@1:0,1,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Before Audio LPF</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Postfiltering</value></param>
<param><key>name</key><value>Audio Waveform</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>512</value></param>
<param><key>srate</key><value>aud_fs</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>tabset0@2:0,1,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>SAME Baseband</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>SAME BB Envelope</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>Corrected SAME BB</value></param>
<param><key>name</key><value>SAME FSK Baseband</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>8192</value></param>
<param><key>srate</key><value>same_fs</value></param>
<param><key>tr_delay</key><value>symbol_period*128.0</value></param>
<param><key>tr_level</key><value>0.2</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"rx_sob"</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>gui_hint</key><value>tabset0@2:2,1,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Soft Bits</value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>style1</key><value>3</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Hard Bits</value></param>
<param><key>name</key><value>"SAME Clock Recovered Output"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>same_fs/sps</value></param>
<param><key>tr_delay</key><value>10.0/symbol_rate</value></param>
<param><key>tr_level</key><value>0.35</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"rx_sob"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0</value></param>
<param><key>gui_hint</key><value>tabset0@3:0,0,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Soft Bits</value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>style1</key><value>3</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Hard Bits</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>Error</value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value>Instantaneous Period</value></param>
<param><key>color5</key><value>"cyan"</value></param>
<param><key>label5</key><value>Average Period</value></param>
<param><key>name</key><value>"SAME Clock Recovered Output"</value></param>
<param><key>nconnections</key><value>5</value></param>
<param><key>size</key><value>1024*3</value></param>
<param><key>srate</key><value>same_fs/sps</value></param>
<param><key>tr_delay</key><value>10.0/symbol_rate</value></param>
<param><key>tr_level</key><value>0.35</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"rx_sob"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.5</value></param>
<param><key>ymax</key><value>8</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>0.00001</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0_0</value></param>
<param><key>alpha</key><value>0.0001</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0_0_0</value></param>
<param><key>alpha</key><value>0.01</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0_0_0_0</value></param>
<param><key>alpha</key><value>0.01</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabset0</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label0</key><value>RF</value></param>
<param><key>label1</key><value>Audio</value></param>
<param><key>label2</key><value>Digital</value></param>
<param><key>label3</key><value>Clock Recovery</value></param>
<param><key>num_tabs</key><value>4</value></param>
</block>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>analog_pll_carriertracking_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pll_carriertracking_cc_0</source_block_id><sink_block_id>analog_pll_freqdet_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pll_carriertracking_cc_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pll_carriertracking_cc_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pll_carriertracking_cc_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_pll_freqdet_cf_0</source_block_id><sink_block_id>iir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>fir_filter_xxx_0_0_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_tag_gate_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_1</source_block_id><sink_block_id>blocks_nlog10_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>blocks_sub_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>nwr_burst_detect_and_tag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>blocks_nlog10_ff_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_meta_source_0</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>freq_xlating_fft_filter_ccc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_1</source_block_id><sink_block_id>freq_xlating_fft_filter_ccc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>nwr_burst_detect_and_tag_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>goertzel_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0</source_block_id><sink_block_id>blocks_threshold_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0</source_block_id><sink_block_id>qtgui_number_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_1</source_block_id><sink_block_id>qtgui_number_sink_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0_1</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0_1</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>blocks_sub_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0</source_block_id><sink_block_id>qtgui_number_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_float_to_complex_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>freq_xlating_fft_filter_ccc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>fractional_resampler_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>coherent_mark_pll</source_block_id><sink_block_id>blocks_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>coherent_space_pll</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_bb_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0_0_3</source_block_id><sink_block_id>blocks_abs_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0_0_3</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fractional_resampler_xx_0</source_block_id><sink_block_id>iir_filter_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fractional_resampler_xx_0</source_block_id><sink_block_id>iir_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fractional_resampler_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fractional_resampler_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fractional_resampler_xx_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_1</source_block_id><sink_block_id>coherent_mark_pll</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_1</source_block_id><sink_block_id>coherent_space_pll</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>goertzel_fc_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iir_filter_xxx_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iir_filter_xxx_0</source_block_id><sink_block_id>fractional_resampler_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iir_filter_xxx_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iir_filter_xxx_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iir_filter_xxx_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>iir_filter_xxx_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>iir_filter_xxx_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iir_filter_xxx_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>nwr_add_tag_value_ff_0</source_block_id><sink_block_id>nwr_multiply_by_tag_value_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_burst_detect_and_tag_0</source_block_id><sink_block_id>nwr_correction_estimator_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_clock_recovery_mm_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>3</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>nwr_clock_recovery_mm_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>2</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>nwr_clock_recovery_mm_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>nwr_clock_recovery_mm_xx_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_clock_recovery_mm_xx_0</source_block_id><sink_block_id>nwr_same_burst_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_clock_recovery_mm_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_clock_recovery_mm_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_correction_estimator_ff_0</source_block_id><sink_block_id>blocks_tag_debug_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_correction_estimator_ff_0</source_block_id><sink_block_id>nwr_add_tag_value_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_correction_estimator_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_multiply_by_tag_value_ff_0</source_block_id><sink_block_id>nwr_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_multiply_by_tag_value_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>nwr_same_burst_decoder_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>bytes</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>nwr_same_burst_decoder_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>printable</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_file_meta_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fft_filter_ccc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0_0</source_block_id><sink_block_id>blocks_repeat_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0_0_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0_0_0_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
