<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>aausat4_test_3</value></param>
<param><key>author</key><value>Andy Walls</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>AAUSAT Demod Test 3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>value</key><value>2400.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_deviation</value></param>
<param><key>value</key><value>1200.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>100e3</value></param>
<param><key>gui_hint</key><value>tabset0@0:0,0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-200e3</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>200e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>h</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>loop_bandwidth</value></param>
<param><key>value</key><value>0.100</value></param>
<param><key>gui_hint</key><value>tabset0@3:3,0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.010</value></param>
<param><key>step</key><value>0.010</value></param>
<param><key>stop</key><value>0.500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>500000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_2</value></param>
<param><key>value</key><value>samp_rate/4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_3</value></param>
<param><key>value</key><value>samp_rate_2/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_4</value></param>
<param><key>value</key><value>samp_rate_3/1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_5</value></param>
<param><key>value</key><value>samp_rate_4/4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samples_per_symbol</value></param>
<param><key>value</key><value>samp_rate_5/baud_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps1</value></param>
<param><key>value</key><value>firdes.low_pass_2(1.0, samp_rate, 40e3, 22.5e3, 60, firdes.WIN_BLACKMAN_HARRIS)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps1_len</value></param>
<param><key>value</key><value>len(taps1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps2</value></param>
<param><key>value</key><value>firdes.low_pass_2(1.0, samp_rate_2, 21e3, 10.25e3, 60, firdes.WIN_BLACKMAN_HARRIS)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps2_len</value></param>
<param><key>value</key><value>len(taps2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps3</value></param>
<param><key>value</key><value>firdes.low_pass_2(1.0, samp_rate_3, 15.5e3, 0.625e3, 40, firdes.WIN_KAISER, 6.76)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps3_len</value></param>
<param><key>value</key><value>len(taps3)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps4</value></param>
<param><key>value</key><value>firdes.low_pass_2(1.0, samp_rate_4,4.5e3,3.3125e3,60,firdes.WIN_BLACKMAN_HARRIS)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps4_len</value></param>
<param><key>value</key><value>len(taps4)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps5</value></param>
<param><key>value</key><value>firdes.low_pass_2(1.0, samp_rate_5,1.4e3,0.1e3,40,firdes.WIN_KAISER, 6.76)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps5_len</value></param>
<param><key>value</key><value>len(taps5)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_gmpf</value></param>
<param><key>value</key><value>analog.cpm.phase_response(analog.cpm.GAUSSIAN, int(samples_per_symbol), 3, 0.5)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_gmpf_len</value></param>
<param><key>value</key><value>len(taps_gmpf)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_ma</value></param>
<param><key>value</key><value>[1/round(4 / baud_rate * samp_rate_4)]*int(round(4 / baud_rate * samp_rate_4))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_ma_len</value></param>
<param><key>value</key><value>len(taps_ma)</value></param>
</block>
<block>
<key>aausat_aausat4_beacon_parser</key>
<param><key>id</key><value>aausat_aausat4_beacon_parser_0</value></param>
</block>
<block>
<key>aausat_aausat4_fec</key>
<param><key>id</key><value>aausat_aausat4_fec_0</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>comment</key><value>FM discriminator</value></param>
<param><key>gain</key><value>((samp_rate_5/2.0)/math.pi)/freq_deviation</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>int((taps_ma_len-1)/2)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_1</value></param>
<param><key>delay</key><value>int((taps_gmpf_len-1)/2.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/andy/grcs/aausat/iq_from_osmocom_source_downsamp_to_62500.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>begin_tag</key><value>pmt.intern("START")</value></param>
<param><key>file</key><value>/home/andy/grcs/aausat/iq_from_osmocom_source_direct_File_Sink.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate*10</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_xx_0</value></param>
<param><key>access_code</key><value>010011110101101000110100010000110101010101000010</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>"oz4cub"</value></param>
<param><key>threshold</key><value>3</value></param>
</block>
<block>
<key>digital_symbol_sync_xx</key>
<param><key>id</key><value>digital_symbol_sync_xx_0</value></param>
<param><key>damping</key><value>1.0</value></param>
<param><key>ted_gain</key><value>0.263</value></param>
<param><key>type</key><value>ff</value></param>
<param><key>resamp_type</key><value>digital.IR_MMSE_8TAP</value></param>
<param><key>loop_bw</key><value>loop_bandwidth</value></param>
<param><key>max_dev</key><value>1.0</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>samples_per_symbol</value></param>
<param><key>ted_type</key><value>digital.TED_ZERO_CROSSING</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_1</value></param>
<param><key>comment</key><value>Filtering stage</value></param>
<param><key>decim</key><value>samp_rate_3/samp_rate_4</value></param>
<param><key>taps</key><value>taps3</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_1_0_0</value></param>
<param><key>comment</key><value>IF/Channel filter</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_delay</key><value>int((taps5_len - 1)/2)</value></param>
<param><key>taps</key><value>taps5</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_2</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>taps_ma</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_1</value></param>
<param><key>comment</key><value>Resampling stage 2: /2</value></param>
<param><key>decim</key><value>samp_rate_2/samp_rate_3</value></param>
<param><key>taps</key><value>taps2</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_2</value></param>
<param><key>comment</key><value>Resampling stage 3: /4</value></param>
<param><key>decim</key><value>int(samp_rate_4/samp_rate_5)</value></param>
<param><key>samp_delay</key><value>int((taps4_len - 1)/2)</value></param>
<param><key>taps</key><value>taps4</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_delay</key><value>int((taps_gmpf_len-1)/2)</value></param>
<param><key>taps</key><value>taps_gmpf</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>freq_offset</value></param>
<param><key>comment</key><value>Resampling stage 1: /4</value></param>
<param><key>decim</key><value>samp_rate/samp_rate_2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>taps1</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>from gnuradio import analog</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>FIXME: Inject dynamic noise estimates here in messages</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>FIXME: TED gain is a wild guess</value></param>
</block>
<block>
<key>nwr_add_tag_value_ff</key>
<param><key>id</key><value>nwr_add_tag_value_ff_0</value></param>
<param><key>tagname</key><value>"offset_corr"</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>nwr_burst_detect_and_tag</key>
<param><key>id</key><value>nwr_burst_detect_and_tag_0</value></param>
<param><key>guard_interval</key><value>1.0 / baud_rate * 1 * 8</value></param>
<param><key>declare_dur</key><value>1.0 / baud_rate * 8 * (60+6+1+(2+4+23+2+32+1)*2*0-16)</value></param>
<param><key>eob_delay</key><value>1.0 / baud_rate * 3</value></param>
<param><key>eob_key</key><value>"rx_eob"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>init_floor_est</key><value>(1.7530e-6)</value></param>
<param><key>max_dur</key><value>1.0 / baud_rate * 8 * (60+6+1+(2+4+84+2+32+1)*2+16)</value></param>
<param><key>sob_amp_frac</key><value>0.2</value></param>
<param><key>sample_rate</key><value>samp_rate_4</value></param>
<param><key>sob_key</key><value>"rx_sob"</value></param>
<param><key>thresh_db</key><value>-6</value></param>
</block>
<block>
<key>nwr_correction_estimator_ff</key>
<param><key>id</key><value>nwr_correction_estimator_ff_0</value></param>
<param><key>clock_est_key</key><value>"ignore_clock_est"</value></param>
<param><key>eob_key</key><value>"rx_eob"</value></param>
<param><key>peak_ref</key><value>0.425</value></param>
<param><key>trough_ref</key><value>-0.425</value></param>
<param><key>inspection_length</key><value>int(samples_per_symbol*24)</value></param>
<param><key>inspection_offset</key><value>int(samples_per_symbol*12)</value></param>
<param><key>offset_corr_key</key><value>"offset_corr"</value></param>
<param><key>scale_corr_key</key><value>"scale_corr"</value></param>
<param><key>scale_eob_zero</key><value>False</value></param>
<param><key>sob_key</key><value>"rx_sob"</value></param>
<param><key>timing_win_end</key><value>int(samples_per_symbol*20)</value></param>
<param><key>timing_win_start</key><value>int(samples_per_symbol*12)</value></param>
<param><key>time_est_key</key><value>"time_est"</value></param>
</block>
<block>
<key>nwr_fsk_cps_cfo_est_cc</key>
<param><key>id</key><value>nwr_fsk_cps_cfo_est_cc_0</value></param>
<param><key>baud_rate</key><value>baud_rate</value></param>
<param><key>beta</key><value>4.55</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>interval</key><value>1.07</value></param>
<param><key>mod_index</key><value>h</value></param>
<param><key>output_tag</key><value>"cfo_est"</value></param>
<param><key>periodic</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate_4</value></param>
<param><key>sob_tag</key><value>"rx_sob"</value></param>
<param><key>tolerance</key><value>baud_rate * 0.1</value></param>
<param><key>wintype</key><value>fft.window.WIN_BLACKMAN_HARRIS</value></param>
</block>
<block>
<key>nwr_multiply_by_tag_value_ff</key>
<param><key>id</key><value>nwr_multiply_by_tag_value_ff_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>tagname</key><value>"scale_corr"</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>nwr_rotate_by_tag_value_cc</key>
<param><key>id</key><value>nwr_rotate_by_tag_value_cc_0</value></param>
<param><key>scale_factor</key><value>-math.pi/(samp_rate_4/2.0)</value></param>
<param><key>tagname</key><value>cfo_est</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>pdu_utils_pack_unpack</key>
<param><key>id</key><value>pdu_utils_pack_unpack_0</value></param>
<param><key>bit_order</key><value>pdu_utils.BIT_ORDER_MSB_FIRST</value></param>
<param><key>mode</key><value>pdu_utils.MODE_PACK_BYTE</value></param>
</block>
<block>
<key>pdu_utils_tags_to_pdu_X</key>
<param><key>id</key><value>pdu_utils_tags_to_pdu_X_0</value></param>
<param><key>boost_time</key><value>False</value></param>
<param><key>cfg_port</key><value>False</value></param>
<param><key>eob_alignment</key><value>1</value></param>
<param><key>eob_offset</key><value>0</value></param>
<param><key>pub_det</key><value>False</value></param>
<param><key>end_tag</key><value>"ignore_rx_eob"</value></param>
<param><key>max_pdu_size</key><value>2048</value></param>
<param><key>type</key><value>b</value></param>
<param><key>prepend</key><value>[]</value></param>
<param><key>rate</key><value>samp_rate_5</value></param>
<param><key>start_tag</key><value>"oz4cub"</value></param>
<param><key>start_time</key><value>0.0</value></param>
<param><key>tail_size</key><value>0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate_4</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>8192</value></param>
<param><key>gui_hint</key><value>tabset0@1:0,0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>Uncorrected</value></param>
<param><key>label2</key><value>Corrected</value></param>
<param><key>name</key><value>"IF1 Spectrum"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>tr_level</key><value>-80</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"rx_sob"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>8192</value></param>
<param><key>gui_hint</key><value>tabset0@0:1,0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"Spectrum"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>tr_level</key><value>-80.0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_KAISER</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_1</value></param>
<param><key>bw</key><value>samp_rate_5</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>8192</value></param>
<param><key>gui_hint</key><value>tabset0@2:0,0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>No Channel Filter</value></param>
<param><key>label2</key><value>Channel Filtered</value></param>
<param><key>name</key><value>"IF2 Spectrum"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"rx_sob"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>tabset0@1:1,0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Re{Corrected}</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Im{Corrected}</value></param>
<param><key>name</key><value>"IF1 Signal"</value></param>
<param><key>size</key><value>4096</value></param>
<param><key>srate</key><value>samp_rate_4</value></param>
<param><key>tr_delay</key><value>0.003</value></param>
<param><key>tr_level</key><value>0.1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"rx_sob"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>1.1</value></param>
<param><key>ymin</key><value>-1.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>gui_hint</key><value>tabset0@2:1,0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Re{Burst}</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Im{Burst}</value></param>
<param><key>name</key><value>IF2 Filtered Signal</value></param>
<param><key>size</key><value>4096*4</value></param>
<param><key>srate</key><value>samp_rate_5</value></param>
<param><key>tr_delay</key><value>0.02</value></param>
<param><key>tr_level</key><value>0.1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"rx_sob"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ylabel</key><value></value></param>
<param><key>yunit</key><value></value></param>
<param><key>ymax</key><value>1.1</value></param>
<param><key>ymin</key><value>-1.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1_0</value></param>
<param><key>gui_hint</key><value>tabset0@3:0,0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Unfiltered</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Gaussian Filtered</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>Corrected</value></param>
<param><key>name</key><value>Instantaneous Frequency</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>16384+3276</value></param>
<param><key>srate</key><value>samp_rate_5</value></param>
<param><key>tr_delay</key><value>0.02</value></param>
<param><key>tr_level</key><value>0.1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"rx_sob"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>Scaled Frequency Deviation</value></param>
<param><key>yunit</key><value>1200 Hz</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>gui_hint</key><value>tabset0@3:1,0,2,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Symbols</value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>style1</key><value>2</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Error</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>Inst Period</value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value>Avg Period</value></param>
<param><key>name</key><value>"Symbols"</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>4096</value></param>
<param><key>srate</key><value>baud_rate</value></param>
<param><key>tr_delay</key><value>0.005</value></param>
<param><key>tr_level</key><value>0.1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"rx_sob"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>9</value></param>
<param><key>ymin</key><value>-1.2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>gui_hint</key><value>tabset0@4:0,0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Hard bits</value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>style1</key><value>2</value></param>
<param><key>name</key><value>"Syncword"</value></param>
<param><key>size</key><value>512</value></param>
<param><key>srate</key><value>baud_rate</value></param>
<param><key>tr_delay</key><value>0.025</value></param>
<param><key>tr_level</key><value>1.1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"oz4cub"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2.2</value></param>
<param><key>ymin</key><value>-0.2</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabset0</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>label0</key><value>RF</value></param>
<param><key>label1</key><value>IF1</value></param>
<param><key>label2</key><value>IF2</value></param>
<param><key>label3</key><value>Baseband</value></param>
<param><key>label4</key><value>Bits</value></param>
<param><key>num_tabs</key><value>5</value></param>
</block>
<connection><source_block_id>aausat_aausat4_fec_0</source_block_id><sink_block_id>aausat_aausat4_beacon_parser_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>blocks_delay_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>fir_filter_xxx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>fft_filter_xxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>nwr_burst_detect_and_tag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0</source_block_id><sink_block_id>pdu_utils_tags_to_pdu_X_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_1</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_1</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_1</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_1_0_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_1_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_1_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_2</source_block_id><sink_block_id>nwr_burst_detect_and_tag_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_1</source_block_id><sink_block_id>fft_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_2</source_block_id><sink_block_id>fft_filter_xxx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_2</source_block_id><sink_block_id>qtgui_freq_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_3</source_block_id><sink_block_id>nwr_correction_estimator_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>fir_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_add_tag_value_ff_0</source_block_id><sink_block_id>nwr_multiply_by_tag_value_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_burst_detect_and_tag_0</source_block_id><sink_block_id>nwr_fsk_cps_cfo_est_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_correction_estimator_ff_0</source_block_id><sink_block_id>nwr_add_tag_value_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_correction_estimator_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>nwr_fsk_cps_cfo_est_cc_0</source_block_id><sink_block_id>nwr_rotate_by_tag_value_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_multiply_by_tag_value_ff_0</source_block_id><sink_block_id>digital_symbol_sync_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_multiply_by_tag_value_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>nwr_rotate_by_tag_value_cc_0</source_block_id><sink_block_id>fir_filter_xxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_rotate_by_tag_value_cc_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>nwr_rotate_by_tag_value_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pdu_utils_pack_unpack_0</source_block_id><sink_block_id>aausat_aausat4_fec_0</sink_block_id><source_key>pdu_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pdu_utils_pack_unpack_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdu_out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>pdu_utils_tags_to_pdu_X_0</source_block_id><sink_block_id>pdu_utils_pack_unpack_0</sink_block_id><source_key>pdu_out</source_key><sink_key>pdu_in</sink_key></connection>
</flow_graph>
