<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>clock_recovery_test_complex</value></param>
<param><key>author</key><value>Andy Walls</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>comment</key><value>Clock Recovery Test
(C) 2016 Andy Walls &lt;awalls.cx18@gmail.com&gt;
This flowgraph and grc data file were generated
by Andy Walls using the GNU Radio Companion
application.
See http://www.gnu.org/licenses/gpl-faq.en.html#GPLOutput</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>value</key><value>1200.0</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>data_src</value></param>
<param><key>value</key><value>4</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label0</key><value>Random</value></param>
<param><key>label1</key><value>Low freq</value></param>
<param><key>label2</key><value>Dot Pattern</value></param>
<param><key>label3</key><value>Pulse</value></param>
<param><key>label4</key><value>Packets</value></param>
<param><key>num_opts</key><value>5</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>option3</key><value>3</value></param>
<param><key>option4</key><value>4</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fn_norm</value></param>
<param><key>value</key><value>0.043</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>label</key><value>Normalized Bandwidth</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>0.25</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_mu</value></param>
<param><key>value</key><value>0.6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>label</key><value>Gain Mu</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.001</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_mu</value></param>
<param><key>value</key><value>2.0*math.exp(zeta*omega_n_norm)*((math.cosh(omega_d_norm) if zeta &gt; 1.0 else math.cos(omega_d_norm))-math.exp(-zeta*omega_n_norm))</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>gain_mu_label</value></param>
<param><key>value</key><value>"%8.6f" % gain_mu</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
<param><key>label</key><value>Gain Mu</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_omega</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Gain Omega</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.001</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_omega</value></param>
<param><key>value</key><value>2.0*math.exp(zeta*omega_n_norm)*(math.cosh(zeta*omega_n_norm)-(math.cosh(omega_d_norm) if zeta &gt; 1.0 else math.cos(omega_d_norm)))</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>gain_omega_label</value></param>
<param><key>value</key><value>"%8.6f" % gain_omega</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>label</key><value>Gain Omega</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>omega_d_norm</value></param>
<param><key>value</key><value>omega_n_norm*math.sqrt((zeta*zeta-1.0) if zeta &gt; 1.0 else (1.0-zeta*zeta))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>omega_n_norm</value></param>
<param><key>value</key><value>2.0*math.pi*fn_norm</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>osps</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable_tag_object</key>
<param><key>id</key><value>packet_time_est_tag</value></param>
<param><key>key</key><value>pmt.intern("test")</value></param>
<param><key>offset</key><value>9</value></param>
<param><key>src</key><value>pmt.intern("packet_vector_source")</value></param>
<param><key>value</key><value>pmt.from_double(0.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>zeta</value></param>
<param><key>value</key><value>1.5</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Damping Factor</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.1</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>5.0</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>16384</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_abs_xx</key>
<param><key>id</key><value>blocks_abs_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>num_inputs</key><value>5</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_2</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>int((sps-1.0)/2.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_1_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_2</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_2_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_3</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>sps</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1.0/sps</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1 if data_src == 4 else 0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>1 if data_src == 3 else 0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>1 if data_src == 2 else 0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_0</value></param>
<param><key>const</key><value>1 if data_src == 1 else 0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_0_0</value></param>
<param><key>const</key><value>1 if data_src == 0 else 0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>0.707+0.707j</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>interp</key><value>sps*2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_1_0</value></param>
<param><key>comment</key><value>Turn on to sync up right away at each time_est tag</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>baud_rate*10</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>(0, 1, 0, 1, 0, 1, 0, 1)</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>(0,0,0,0,1,1,1,1)</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0_1</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>[1]+[0]*7</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0_1_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>tags</key><value>[packet_time_est_tag]</value></param>
<param><key>vector</key><value>[1,0]*(4*12*0)+[1,1,0,1,0,1,0,1]*12+[1,0,1,1,1,1,1,0,0,1]+[1,1,1,1,0,1,1,0,0,1]+[1,0,1,1,1,1,1,0,0,1]+[0,1,1,1,0,1,1,0,1,0]+[0,0,0,0,0,1,0,1,0,1,1,0,0,1,1,1,0,0,0,0]+[2]*128</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_0</value></param>
<param><key>map</key><value>[-1, 1,0]</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_1_0_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_delay</key><value>int((sps-1.0)/2.0)+4</value></param>
<param><key>taps</key><value>[1.0/float(sps)]*sps</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>nwr_burst_detect_and_tag</key>
<param><key>id</key><value>nwr_burst_detect_and_tag_0_0</value></param>
<param><key>guard_interval</key><value>8.0*10.0/baud_rate</value></param>
<param><key>declare_dur</key><value>8.0/baud_rate</value></param>
<param><key>eob_delay</key><value>0.0</value></param>
<param><key>eob_key</key><value>"rx_eob"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>init_floor_est</key><value>100e-6</value></param>
<param><key>max_dur</key><value>8.0*50.0/baud_rate</value></param>
<param><key>sob_amp_frac</key><value>0.0</value></param>
<param><key>sample_rate</key><value>sps*baud_rate</value></param>
<param><key>sob_key</key><value>"rx_sob"</value></param>
<param><key>thresh_db</key><value>0.0</value></param>
</block>
<block>
<key>nwr_clock_recovery_mm_xx</key>
<param><key>id</key><value>nwr_clock_recovery_mm_xx_0</value></param>
<param><key>damping</key><value>zeta</value></param>
<param><key>type</key><value>cc</value></param>
<param><key>loop_bw</key><value>fn_norm</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>osps</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>nwr_correction_estimator_ff</key>
<param><key>id</key><value>nwr_correction_estimator_ff_0</value></param>
<param><key>clock_est_key</key><value>"clock_est"</value></param>
<param><key>eob_key</key><value>"rx_eob"</value></param>
<param><key>peak_ref</key><value>1.0</value></param>
<param><key>trough_ref</key><value>-1.0</value></param>
<param><key>inspection_length</key><value>sps*10</value></param>
<param><key>offset_corr_key</key><value>"offset_corr"</value></param>
<param><key>scale_corr_key</key><value>"scale_corr"</value></param>
<param><key>scale_eob_zero</key><value>False</value></param>
<param><key>sob_key</key><value>"rx_sob"</value></param>
<param><key>timing_win_end</key><value>sps*9</value></param>
<param><key>timing_win_start</key><value>sps*5</value></param>
<param><key>time_est_key</key><value>"time_est"</value></param>
</block>
<block>
<key>nwr_symbol_sync_xx</key>
<param><key>id</key><value>nwr_symbol_sync_xx_0</value></param>
<param><key>damping</key><value>zeta</value></param>
<param><key>type</key><value>cc</value></param>
<param><key>loop_bw</key><value>fn_norm</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>osps</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>constellation</key><value>digital.constellation_qpsk().base()</value></param>
<param><key>ted_type</key><value>nwr.timing_error_detector.TED_MOD_MUELLER_AND_MULLER</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>Clock Recovery</value></param>
<param><key>label2</key><value>Symbol Sync</value></param>
<param><key>name</key><value>"Recovered Constellations"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>50</value></param>
<param><key>tr_level</key><value>0.1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"clock_est"</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Bits</value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>style1</key><value>0</value></param>
<param><key>name</key><value>Bit sequence</value></param>
<param><key>size</key><value>40</value></param>
<param><key>srate</key><value>baud_rate</value></param>
<param><key>tr_level</key><value>0.1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.01</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0</value></param>
<param><key>gui_hint</key><value>3,1,1,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Soft Bits Re</value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>color2</key><value>"magenta"</value></param>
<param><key>label2</key><value>Soft Bits Im</value></param>
<param><key>marker2</key><value>0</value></param>
<param><key>color3</key><value>"red"</value></param>
<param><key>label3</key><value>Error Re</value></param>
<param><key>color4</key><value>"dark red"</value></param>
<param><key>label4</key><value>Error Im</value></param>
<param><key>style4</key><value>0</value></param>
<param><key>color5</key><value>"green"</value></param>
<param><key>label5</key><value>Instantaneous Period Re</value></param>
<param><key>color6</key><value>"dark green"</value></param>
<param><key>label6</key><value>Instantaneous Period Im</value></param>
<param><key>style6</key><value>0</value></param>
<param><key>color7</key><value>"black"</value></param>
<param><key>label7</key><value>Average Period Re</value></param>
<param><key>color8</key><value>"black"</value></param>
<param><key>label8</key><value>Average Period Im</value></param>
<param><key>style8</key><value>0</value></param>
<param><key>name</key><value>Clock Recovered Output and Debug</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>256*osps</value></param>
<param><key>srate</key><value>baud_rate*osps</value></param>
<param><key>tr_delay</key><value>0.01</value></param>
<param><key>tr_level</key><value>0.1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>tr_tag</key><value>"time_est"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>ymax</key><value>sps+2</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0_0</value></param>
<param><key>gui_hint</key><value>4,1,1,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Soft Bits Re</value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>color2</key><value>"magenta"</value></param>
<param><key>label2</key><value>Soft Bits Im</value></param>
<param><key>marker2</key><value>0</value></param>
<param><key>color3</key><value>"red"</value></param>
<param><key>label3</key><value>Error Re</value></param>
<param><key>color4</key><value>"dark red"</value></param>
<param><key>label4</key><value>Error Im</value></param>
<param><key>style4</key><value>0</value></param>
<param><key>color5</key><value>"green"</value></param>
<param><key>label5</key><value>Instantaneous Period Re</value></param>
<param><key>color6</key><value>"dark green"</value></param>
<param><key>label6</key><value>Instantaneous Period Im</value></param>
<param><key>style6</key><value>0</value></param>
<param><key>color7</key><value>"black"</value></param>
<param><key>label7</key><value>Average Period Re</value></param>
<param><key>color8</key><value>"black"</value></param>
<param><key>label8</key><value>Average Period Im</value></param>
<param><key>style8</key><value>0</value></param>
<param><key>name</key><value>Symbol Synched Output and Debug</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>256*osps</value></param>
<param><key>srate</key><value>baud_rate*osps</value></param>
<param><key>tr_delay</key><value>0.01</value></param>
<param><key>tr_level</key><value>0.1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>tr_tag</key><value>"time_est"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>ymax</key><value>sps+2</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1_0</value></param>
<param><key>gui_hint</key><value>3,0,2,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Re</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Im</value></param>
<param><key>size</key><value>1024*3</value></param>
<param><key>srate</key><value>baud_rate*sps</value></param>
<param><key>tr_delay</key><value>0.01</value></param>
<param><key>tr_level</key><value>0.1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"time_est"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>21</value></param>
<param><key>fbw</key><value>0.45</value></param>
<param><key>interp</key><value>10</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_2</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>nwr_burst_detect_and_tag_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>digital_map_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_2</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_2_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_3</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>nwr_burst_detect_and_tag_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_tag_gate_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_1_0</source_block_id><sink_block_id>nwr_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_1_0</source_block_id><sink_block_id>nwr_symbol_sync_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0_1_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_0</source_block_id><sink_block_id>blocks_char_to_float_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_1_0_0_0</source_block_id><sink_block_id>blocks_abs_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_1_0_0_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_burst_detect_and_tag_0_0</source_block_id><sink_block_id>nwr_correction_estimator_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_clock_recovery_mm_xx_0</source_block_id><sink_block_id>blocks_float_to_complex_2</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_clock_recovery_mm_xx_0</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_clock_recovery_mm_xx_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_clock_recovery_mm_xx_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_clock_recovery_mm_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_correction_estimator_ff_0</source_block_id><sink_block_id>blocks_float_to_complex_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_symbol_sync_xx_0</source_block_id><sink_block_id>blocks_float_to_complex_2_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_symbol_sync_xx_0</source_block_id><sink_block_id>blocks_float_to_complex_1_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_symbol_sync_xx_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_symbol_sync_xx_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>nwr_symbol_sync_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>fir_filter_xxx_0_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
